# Keil uVision project rt1064.uvprojx, settings and files
target nor_sdram_zf_dtcm (6210000::V6.21::ARMCLANG)
  device: MIMXRT1064DVL6B NXP
  pack: NXP.MIMXRT1064_DFP.19.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) IROM2(0x00200000,0x020000) XRAM(0x20280000,0x040000) XRAM2(0x20200000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt1064 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=1
  c define: CPU_MIMXRT1064DVL6A,SKIP_SYSCLK_INIT,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_DCD_ENABLE =1, XIP_BOOT_HEADER_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1, FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0, USB_STACK_BM, DEBUG, MCUXPRESSO_SDK, SD_ENABLED
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb -Wno-invalid-source-encoding
  c include: ..\user\inc;..\code;..\..\libraries\sdk\startup\mdk;..\..\libraries\sdk\deceive;..\..\libraries\sdk\drives;..\..\libraries\sdk\xip;..\..\libraries\sdk\utilities;..\..\libraries\sdk\utilities\debug_console;..\..\libraries\sdk\utilities\str;..\..\libraries\sdk\cmsis_drivers;..\..\libraries\sdk\CMSIS\Include;..\..\libraries\sdk\CMSIS\Driver\Include;..\..\libraries\sdk\components\lists;..\..\libraries\sdk\components\osa;..\..\libraries\sdk\components\serial_manager;..\..\libraries\sdk\components\uart;..\..\libraries\sdk\board;..\..\libraries\components\fatfs\source;..\..\libraries\components\fatfs\source\fsl_sd_disk;..\..\libraries\components\sdmmc;..\..\libraries\components\sdmmc\common;..\..\libraries\components\sdmmc\host\usdhc;..\..\libraries\components\sdmmc\osa;..\..\libraries\components\sdmmc\sd;..\..\libraries\components\usb\device;..\..\libraries\components\usb\include;..\..\libraries\components\usb\phy;..\..\libraries\components\usb\usb_cdc_adapter;..\..\libraries\zf_common;..\..\libraries\zf_driver;..\..\libraries\zf_device;..\..\libraries\zf_components;..\..\libraries\rttherad_libraries\bsp;..\..\libraries\rttherad_libraries\include;..\..\libraries\rttherad_libraries\include\libc;..\..\libraries\rttherad_libraries\components\finsh;..\code\inc;..\mdk
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..\..\libraries\rttherad_libraries\libcpu\arm\cortex-m7
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT5: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20280000 size 0x40000
  memory RVCT7: RAM 0x20200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\scf\MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler
  group user_c
    ../user/src/: isr.c main.c user_math.c
  group user_h
    ../user/inc/: isr.h user_math.h
  group code
    ../code/src/: Attitude_algorithm.c car.c debug_tool.c encoder.c motor.c PID.c trace_line.c step_motor.c system_perform.c side_catch.c buzzer.c locate_picture.c my_vision.c circule_handle.c MCXvision.c classify.c art.c cross_handle.c final.c
    ../code/inc/: Attitude_algorithm.h car.h config.h debug_tool.h encoder.h motor.h myuart.h PID.h vofa.h trace_line.h step_motor.h system_perform.h side_catch.h buzzer.h locate_picture.h my_vision.h circule_handle.h MCXvision.h classify.h art.h
    ./: camera.c camera.h
  group doc
    ../../libraries/doc/: GPL3_permission_statement.txt read me.txt version.txt
  group zf_common
    ../../libraries/zf_common/: zf_common_clock.c zf_common_clock.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h zf_common_headfile.h zf_common_interrupt.c zf_common_interrupt.h zf_common_typedef.h zf_common_vector.c zf_common_vector.h
  group zf_driver
    ../../libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_csi.c zf_driver_csi.h zf_driver_delay.c zf_driver_delay.h zf_driver_encoder.c zf_driver_encoder.h zf_driver_exti.c zf_driver_exti.h zf_driver_flash.c zf_driver_flash.h zf_driver_flexio_csi.c zf_driver_flexio_csi.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_iic.c zf_driver_iic.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_romapi.c zf_driver_romapi.h zf_driver_sdio.c zf_driver_sdio.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_soft_spi.c zf_driver_soft_spi.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h zf_driver_usb_cdc.c zf_driver_usb_cdc.h zf_qtimer.c zf_qtimer.h zf_iomuxc.c zf_iomuxc.h
  group zf_device
    ../../libraries/zf_device/: zf_device_absolute_encoder.c zf_device_absolute_encoder.h zf_device_bluetooth_ch9141.c zf_device_bluetooth_ch9141.h zf_device_camera.c zf_device_camera.h zf_device_icm20602.c zf_device_icm20602.h zf_device_imu963ra.c zf_device_imu963ra.h zf_device_imu660ra.c zf_device_imu660ra.h zf_device_ips114.c zf_device_ips114.h zf_device_ips200.c zf_device_ips200.h zf_device_key.c zf_device_key.h zf_device_mpu6050.c zf_device_mpu6050.h zf_device_mt9v03x.c zf_device_mt9v03x.h zf_device_mt9v03x_flexio.c zf_device_mt9v03x_flexio.h zf_device_oled.c zf_device_oled.h zf_device_ov7725.c zf_device_ov7725.h zf_device_scc8660.c zf_device_scc8660.h zf_device_scc8660_flexio.c zf_device_scc8660_flexio.h zf_device_tft180.c zf_device_tft180.h zf_device_tsl1401.c zf_device_tsl1401.h zf_device_type.c zf_device_type.h zf_device_virtual_oscilloscope.c zf_device_virtual_oscilloscope.h zf_device_wifi_uart.c zf_device_wifi_uart.h zf_device_wireless_uart.c zf_device_wireless_uart.h zf_device_config.h zf_device_config.lib zf_device_dl1a.c zf_device_dl1a.h zf_device_dl1b.c zf_device_dl1b.h zf_device_wifi_spi.c zf_device_wifi_spi.h zf_device_gnss.c zf_device_gnss.h
  group zf_components
    ../../libraries/zf_components/: seekfree_assistant.c seekfree_assistant.h seekfree_assistant_interface.c seekfree_assistant_interface.h
  group sdk_drivers
    ../../libraries/sdk/drives/: fsl_adc.c fsl_adc.h fsl_adc_etc.c fsl_adc_etc.h fsl_aipstz.c fsl_aipstz.h fsl_aoi.c fsl_aoi.h fsl_bee.c fsl_bee.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_csi.c fsl_csi.h fsl_dcdc.c fsl_dcdc.h fsl_dcp.c fsl_dcp.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_elcdif.c fsl_elcdif.h fsl_enc.c fsl_enc.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flexcan.c fsl_flexcan.h fsl_flexcan_edma.c fsl_flexcan_edma.h fsl_flexio.c fsl_flexio.h fsl_flexio_camera.c fsl_flexio_camera.h fsl_flexio_camera_edma.c fsl_flexio_camera_edma.h fsl_flexio_i2c_master.c fsl_flexio_i2c_master.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_edma.c fsl_flexio_i2s_edma.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_flexio_mculcd_edma.c fsl_flexio_mculcd_edma.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_flexio_uart.c fsl_flexio_uart.h fsl_flexio_uart_edma.c fsl_flexio_uart_edma.h fsl_flexram.c fsl_flexram.h fsl_flexram_allocate.c fsl_flexram_allocate.h fsl_flexspi.c fsl_flexspi.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_kpp.c fsl_kpp.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_ocotp.c fsl_ocotp.h fsl_pit.c fsl_pit.h fsl_pmu.c fsl_pmu.h fsl_pwm.c fsl_pwm.h fsl_pxp.c fsl_pxp.h fsl_qtmr.c fsl_qtmr.h fsl_rtwdog.c fsl_rtwdog.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_semc.c fsl_semc.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_snvs_lp.c fsl_snvs_lp.h fsl_spdif.c fsl_spdif.h fsl_spdif_edma.c fsl_spdif_edma.h fsl_src.c fsl_src.h fsl_tempmon.c fsl_tempmon.h fsl_trng.c fsl_trng.h fsl_tsc.c fsl_tsc.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
  group sdk_device
    ../../libraries/sdk/board/: board.c board.h clock_config.c clock_config.h pin_mux.c
    ../../libraries/sdk/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c evkmimxrt1064_sdram_ini_dcd.h evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_flexspi_nor_config.h evkmimxrt1064_flexspi_nor_config.c
    ../../libraries/sdk/deceive/: system_MIMXRT1064.h system_MIMXRT1064.c MIMXRT1064_features.h MIMXRT1064.h fsl_device_registers.h
    ../../libraries/sdk/startup/mdk/: startup_MIMXRT1064.S
    ../../libraries/sdk/utilities/: fsl_assert.c
    ../../libraries/sdk/components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
    ../../libraries/sdk/components/lists/: fsl_component_generic_list.c
    ../../libraries/sdk/components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
    ../../libraries/sdk/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group components_fatfs
    ../../libraries/components/fatfs/source/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
    ../../libraries/components/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group components_sdmmc
    ../../libraries/components/sdmmc/: sdmmc_config.c sdmmc_config.h
    ../../libraries/components/sdmmc/common/: fsl_sdmmc_common.c fsl_sdmmc_common.h fsl_sdmmc_spec.h
    ../../libraries/components/sdmmc/host/usdhc/: fsl_sdmmc_host.h
    ../../libraries/components/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
    ../../libraries/components/sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
    ../../libraries/components/sdmmc/sd/: fsl_sd.c fsl_sd.h
  group components_usb
    ../../libraries/components/usb/device/: usb_device_ehci.c usb_device_ehci.h usb_device_dci.c usb_device_dci.h usb_device.h
    ../../libraries/components/usb/include/: usb.h usb_misc.h usb_spec.h
    ../../libraries/components/usb/phy/: usb_phy.c usb_phy.h
    ../../libraries/components/usb/usb_cdc_adapter/: usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_class.c usb_device_class.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h
  group rt_thread_src
    ../../libraries/rttherad_libraries/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group rt_thread_inc
    ../../libraries/rttherad_libraries/include/: rtdbg.h rtdebug.h rtdef.h rthw.h rtlibc.h rtm.h rtservice.h rtthread.h
  group rt_thread_finsh
    ../../libraries/rttherad_libraries/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_file.c shell.c symbol.c
  group rt_thread_cpu_port
    ../../libraries/rttherad_libraries/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
